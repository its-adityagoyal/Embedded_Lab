# Keil uVision project LED_LOOP.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: LED_LOOP +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LED_LOOP.A51
